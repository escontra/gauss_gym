Commit message: integrate t1 with gaussian rendering

File: resources/robots/t1/urdf/T1_locomotion.urdf (robot description, URDF)
Before this commit: robot T1, 24 links, 23 joints
Joints:
- joint AAHead_yaw: type fixed -> revolute
- joint Head_pitch: type fixed -> revolute
